# Keil uVision project BH-F103 .uvprojx, settings and files
target GPS (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\FATFS;..\..\User\FATFS\option;..\..\User\Bsp;..\..\User\nmea_decode\include;..\..\system;..\..\User\jt808\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_it.c nema_decode_test.c
  group BSP
    ../../User/Bsp/gps/: gps_config.c
    ../../User/Bsp/led/: bsp_led.c
    ../../User/Bsp/usart/: usart.c
    ../../User/Bsp/key/: key.c
    ../../User/Bsp/usart2/: usart2.c
    ../../User/Bsp/ec20/: ec20.c
    ../../User/Bsp/internal_flash/: bsp_internal_flash.c
  group nmealib
    ../../User/nmea_decode/src/: context.c generate.c generator.c gmath.c info.c parse.c parser.c sentence.c time.c tok.c
  group system
    ../../system/sys/: sys.c
    ../../system/delay/: delay.c
  group jt808
    ../../User/jt808/src/: bcd.c client_manager.c jt808_packager.c jt808_parser.c location_report.c terminal_register.c util.c set_terminal_parameter.c
  group FatFs
    ../../User/FATFS/: diskio.c ff.c
    ../../User/FATFS/drivers/: fatfs_flash_spi.c fatfs_sd_sdio.c
    ../../User/FATFS/option/: ccsbcs.c
